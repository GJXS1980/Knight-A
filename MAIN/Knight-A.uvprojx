# Keil uVision project Knight-A.uvprojx, settings and files
target Knight-A (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Knight-A +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,EMPL,MPU9250,EMPL_TARGET_STM32F4
  c include: ..\FWLIB\inc;..\CORE;..\DSP_LIB\Include;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\MAIN;..\SENSOR\ADC;..\SENSOR\BEEP;..\SENSOR\CONTROL;..\SENSOR\ENCODER;..\SENSOR\HS485HB;..\SENSOR\IWDG;..\SENSOR\MPU9250;..\SENSOR\MPU9250\IIC;..\SENSOR\MPU9250\MPL\driver\eMPL;..\SENSOR\MPU9250\MPL\driver\include;..\SENSOR\MPU9250\MPL\driver\stm32L;..\SENSOR\MPU9250\MPL\eMPL-hal;..\SENSOR\MPU9250\MPL\mllite;..\SENSOR\MPU9250\MPL\mpl;..\SENSOR\OLED\SPI;..\SENSOR\OLED;..\SENSOR\PWM;..\SENSOR\TMIER;..\SENSOR\URF02;..\SENSOR\WWDG;..\SENSOR\STOP;..\SENSOR\RTC;..\protocol\com
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Communication protocol
    ../protocol/com/: command.c
  group MAIN
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
    ../: readme.txt
  group SENSOR
    ../SENSOR/ADC/: adc.c
    ../SENSOR/BEEP/: beep.c
    ../SENSOR/CONTROL/: control.c
    ../SENSOR/ENCODER/: encoder.c
    ../SENSOR/HS485HB/: hs485hb.c
    ../SENSOR/IWDG/: iwdg.c
    ../SENSOR/MPU9250/IIC/: myiic.c
    ../SENSOR/MPU9250/: mpu9250.c
    ../SENSOR/OLED/: OLED.c
    ../SENSOR/OLED/SPI/: SPI.c
    ../SENSOR/PWM/: pwm.c
    ../SENSOR/TMIER/: timer.c TIM_6_7.c
    ../SENSOR/URF02/: urf02.c
    ../SENSOR/WWDG/: wwdg.c
    ../SENSOR/STOP/: stop.c
    ../SENSOR/RTC/: rtc.c
  group MPL
    ../SENSOR/MPU9250/MPL/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../SENSOR/MPU9250/MPL/driver/stm32L/: log_stm32.c
    ../SENSOR/MPU9250/MPL/eMPL-hal/: eMPL_outputs.c
    ../SENSOR/MPU9250/MPL/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
    ../SENSOR/MPU9250/MPL/mpl/: libmpllib.lib
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_dma.c stm32f4xx_rtc.c stm32f4xx_pwr.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group SYSTEM
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
